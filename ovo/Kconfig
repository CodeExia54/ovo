## ovo/Kconfig
```kconfig
config PVM_MOD
	tristate "Linux Kernel Module for Safe Memory Access"
	default m
	depends on MODULES
	help
	  Module for Safe Memory Access
```
